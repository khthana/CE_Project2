M_R_FLAG	EQU	20H	;BIT ADDRESS
M_L_FLAG	EQU	22H	;BIT ADDRESS
	
M_L_COUNT	EQU	30H	
M_R_COUNT	EQU	32H

M_L_LIMIT	EQU	34H
M_R_LIMIT	EQU	36H
	ORG	0000H	
	JMP	start
	
	ORG	000BH	
	JMP	MOTOR

	ORG	0040H
START:	ACALL	DELAY_1s
	MOV	P1,#000H
	MOV	DPTR,#0F003H	;INIT	8255	A OUTPUT
	MOV	A,#082H		;		B INPUT
	MOVX	@DPTR,A		;		C OUTPUT

	MOV	DPTR,#0F000H	; OUT A 0F0H;
	MOV	A,#0F0H	
	MOVX	@DPTR,A

	MOV	DPTR,#0F002H	; OUT A 0F0H;
	MOV	A,#00FH	
	MOVX	@DPTR,A

	MOV	TMOD,#00000010B	;SET TIMER 0 MODE 2 AUTO RELOAD
	SETB	EA
	SETB	ET0
	CLR	ES	;DISABLE SERIAL INTERUPT
		
	MOV	TL1,#070H	;COUNTER
	MOV	TH1,#070H	;RELOAD
	
	MOV	M_R_FLAG,#000H
	MOV	M_L_FLAG,#000H
	
	MOV	M_L_COUNT,#000H
	MOV	M_R_COUNT,#000H

	MOV	M_L_LIMIT,#064H	
	MOV 	M_R_LIMIT,#0C8H	
	SETB	TR0	;INIT	TIMER
	SJMP	$
;---------------MOTOR----------------
MOTOR:
	PUSH	ACC
	PUSH	PSW
	
CHK_M_L:
	INC	M_L_COUNT
	MOV	A,M_L_COUNT
	CJNE	A,M_L_LIMIT,CHK_M_R                      	
	CPL	P1.0
	MOV	M_L_COUNT,#000H
CHK_M_R:
	INC	M_R_COUNT
	MOV	A,M_R_COUNT
	CJNE	A,M_R_LIMIT,END_T0         	
	CPL	P1.1	
	MOV	M_R_COUNT,#000H
END_T0:	
	POP	PSW
	POP	ACC
	RETI

;---------DELAY--------------------------------;
DELAY:	
	MOV	R7,#002
DELAY_1:
	MOV 	R6,#0E6H
DELAY_2:
	NOP
	NOP
	DJNZ	R6,DELAY_2
	DJNZ	R7,DELAY_1
	RET

DELAY_10ms:	
	MOV	R7,#010
DELAY_10ms_1:
	MOV	R6,#0E6H
DELAY_10ms_2:
	NOP
	NOP
	DJNZ	R6,DELAY_10ms_2
	DJNZ	R7,DELAY_10ms_1
	RET	

DELAY_100ms:	
	MOV	R7,#100
DELAY_100ms_1:
	MOV	R6,#0E6H
DELAY_100ms_2:
	NOP
	NOP
	DJNZ	R6,DELAY_100ms_2
	DJNZ	R7,DELAY_100ms_1
	RET	
DELAY_1s:
	MOV	R5,#100
DELAY_1s_1:
	ACALL	DELAY_10ms
	DJNZ	R5,DELAY_1s_1
	RET
	END

